.INCLUDE "M32DEF.INC"
.ORG 0
RJMP main
.ORG $002
RJMP rout_0
.ORG $100
main:	SBI DDRA,0
		CBI DDRD,2
		CLR R16
		SER R17
		OUT SFIOR,R16
		OUT PORTD,R17
		LDI R16,$40
		LDI R17,$02
		LDI R18,$56
		LDI R19,$01
		OUT TCNC0,R18
		OUT GICR,R16
		OUT MCUCR,R17
		LDI R21,0
		LDI R22,$05
		OUT SPH,R22
		OUT SPL,R21
		SEI
wait:	RJMP wait
rout_0: OUT TCCR0,R19
		SBI PORTA,0
wait2:	IN R16,0
		RJMP wait2
		CBI PORTA,0
		CLR R17
		OUT TIFR,R19
		OUT TCCR0,R17
		OUT TCNC0,R18
		RETI
		RJMP wait2 		