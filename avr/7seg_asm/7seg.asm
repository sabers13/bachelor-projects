
	.INCLUDE "M32DEF.INC"
	.ORG 0
	RJMP main
	.ORG $100
.DB $3F,$06,$DB,$CF,$E6,$ED,$FD,$07,$FF,$EF
	.ORG $200
main: CLR R18
	  OUT DDRA,R18
	  OUT SFIOR,R18
	  SER R18
	  OUT DDRB,R18
	  OUT DDRC,R18
	  CLR R27
	  LDI R18,35
l1:	  CPI R18,10
	  BRLO exit
	  SUBI R18,10
	  INC R27
	  RJMP l1
exit: LDI R31,$02
	  MOV R30,R18
	  LPM R29,Z
	  MOV R30,R27
	  LPM R26,Z

l3:	  SBI PORTC,0
	  SBI PORTC,1
	  OUT PORTB,R29
	  CBI PORTC,0
	  SBI PORTC,0
	  OUT PORTB,R26
	  CBI PORTC,1
	  SBI PORTC,1
	  ;OUT PORTB,R21
	  RJMP l3

